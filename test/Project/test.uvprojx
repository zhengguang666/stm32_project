# Keil uVision project test.uvprojx, settings and files
target test (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS;..\User;..\Libraries\FWlib\inc;..\User\Led;..\User\Lcd;..\User\usart;..\User\i2c;..\User\touch;..\User\SysTick;..\User\led;..\User\key;..\User\spi;..\User\iso;..\User\dht11;..\User\ds18b20;..\User\ov7725;..\User\adc;..\User\breathinglight;..\User\rda5807m;..\User\enc28j60;..\User\can;..\User\rtc;..\User\sram;..\User\norflash;..\User\usb\Mass_Storage\inc;..\User\usb\STM32_USB-FS-Device_Driver\inc;..\User\usb;..\User\sdcard;..\User\nandflash;..\User\ff9;..\User\ff9\option;..\User\iis;..\User\pcm1770;..\User\mp3\pub;..\User\sim900a;..\User\stepmotor;..\User\timer;..\User\ble;..\User\flash;..\User\usart;..\User\sim800l;..\User\BMP085\inc;..\Libraries\CMSIS\startup;..\User\crc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group BSP-ISO
    ../User/iso/: bsp_iso_test.c
  group BSP-USART
    ../User/usart/: bsp_usart1.c bsp_usart2.c printf_init.c
  group BSP-LED
    ../User/led/: bsp_led.c
  group TIMER
    ../User/timer/: TIMER.c
  group FLASH
    ../User/flash/: FLASH.c
  group SIM800L
    ../User/sim800l/: SIM800L.C
  group KEY
    ../User/key/: bsp_key.c
  group CRC
    ../User/crc/: crc.c
